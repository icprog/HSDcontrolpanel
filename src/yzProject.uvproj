# Keil uVision project yzProject.uvproj, settings and files
target ROM (ARM-ADS)
  device: STM32F103VC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: uCOS +hex
  c flags: Optim=1
  c include: .\Lib;.\OS
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group APP
    ./APP/: main.c ModbusTask.c uartCom.c canTask.c modbus_cfg.c powerManage.c pduCom.c lcd.c task_IcCard.c
    ./mod/mcp2515/: mcp2515.c
    ./mod/moduleCom/: moduleCom.c
  group BSP
    ./APP/: startup_stm32f10x_hd.s stm32f10x_it.c BSP.c EEPROM24c16.c
    ./Lib/: core_cm3.c misc.c stm32f10x_rcc.c stm32f10x_gpio.c system_stm32f10x.c stm32f10x_conf.h stm32f10x_can.c stm32f10x_usart.c stm32f10x_iwdg.c stm32f10x_dma.c stm32f10x_adc.c stm32f10x_i2c.c stm32f10x_tim.c stm32f10x_pwr.c
  group uCOS2
    ./OS/: os_core.c os_cpu_c.c os_dbg.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c os_cpu_a.asm
  group readme
    ./APP/: 说明.txt
target RAM (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: uCOS +hex
  c flags: Optim=1
  c define: ProgarmRunRAM
  c include: .\Lib;.\OS;.\LCD
  memory RVCT4: ROM 0x20000000 size 0x8000
  memory RVCT9: RAM 0x20008000 size 0x6000
